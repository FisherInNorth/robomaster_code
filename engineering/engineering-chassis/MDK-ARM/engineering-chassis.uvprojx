# Keil uVision project engineering-chassis.uvprojx, settings and files
target engineering-chassis (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: engineering-chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP\BSP_Chassis;..\APP\PID;..\APP\kinematics;..\BSP\BSP_Can;..\BSP\BSP_Rescue_card;..\BSP\BSP_Rescue_claw;..\Task\TIM6_Cnt_Task;..\BSP\BSP_Motor;..\BSP\BSP_Usart;..\APP\algorithm
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../APP/PID/: pid.c
    ../APP/kinematics/: kinematics.c
    ../APP/algorithm/: algorithm.c
  group BSP
    ../BSP/BSP_Chassis/: BSP_Chassis.c
    ../BSP/BSP_Can/: BSP_Can.c
    ../BSP/BSP_Rescue_card/: BSP_Rescue_card.c
    ../BSP/BSP_Rescue_claw/: BSP_Rescue_claw.c
    ../BSP/BSP_Motor/: BSP_Motor.h
    ../BSP/BSP_Usart/: BSP_Usart.c
  group TASK
    ../Task/TIM6_Cnt_Task/: TIM6_Cnt_Task.c
software components: CMSIS:CORE 4.3.0
